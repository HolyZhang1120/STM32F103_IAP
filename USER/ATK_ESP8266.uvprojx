# Keil uVision project ATK_ESP8266.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ATK_ESP8266 +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "#L"
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\ATK-ESP8266;..\CORE;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\24CXX;..\HARDWARE\IIC;..\HARDWARE\KEY;..\HARDWARE\LCD;..\HARDWARE\LED;..\HARDWARE\SDIO;..\HARDWARE\SPI;..\HARDWARE\TIMER;..\HARDWARE\TOUCH;..\HARDWARE\USART3;..\HARDWARE\W25QXX;..\MALLOC;..\STM32F10x_FWLib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\TEXT;..\USER;..\cJson;..\PICTURE;..\HARDWARE\RTC;..\HARDWARE\DHT11;..\HARDWARE\WDG;..\HARDWARE\CRC32;..\HARDWARE\STMFLASH;..\IAP
  memory RVCT4: ROM 0x8000000 size 0x5000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/24CXX/: 24cxx.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/SPI/: spi.c
    ../HARDWARE/W25QXX/: w25qxx.c
    ../HARDWARE/WDG/: wdg.c
    ../HARDWARE/STMFLASH/: stmflash.c
    ../HARDWARE/KEY/: key.c
  group FWLIB
    ../STM32F10x_FWLib/src/: stm32f10x_usart.c stm32f10x_spi.c stm32f10x_i2c.c stm32f10x_gpio.c stm32f10x_flash.c stm32f10x_exti.c stm32f10x_dbgmcu.c misc.c stm32f10x_rcc.c stm32f10x_iwdg.c
  group MALLOC
    ../MALLOC/: malloc.c
